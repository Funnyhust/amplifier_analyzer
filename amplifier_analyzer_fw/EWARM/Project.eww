<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\amplifier_analyzer_fw.ewp</path>
  </project>
  <batchBuild />
</workspace>
